Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Sculpt\Sculpt Tile Assembly A & A1.IFC
Time: 2024-11-01T11:19:18+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 39.7449474644837437; Volume Measure: 0.0397449474644837; Area Measure: 9.6560906718801895

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 39.7449474644837437; Volume Measure: 0.0397449474644837; Area Measure: 9.6560906718801895

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 39.7449474644837437; Volume Measure: 0.0397449474644837; Area Measure: 9.6560906718801895

# IfcBuildingElementProxy (5)
In: default BuildingStorey
Name | Description | PartNo | Revision | Material | Finish | CheckedBy | DrawnBy | Client | Project | sets with these values
Sculpt Tile Assembly A & A1 | PSet_Mass_Property - Mass Measure: 39.7449474644837437; Volume Measure: 0.0397449474644837; Area Measure: 9.6560906718801895
Sculpt Tile A | SCULPT TILE A | E3DS-66-A-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | SHAPE CUT THRU PANEL FULL DEPTH | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
Sculpt Tile A-1 | SCULPT TILE A | E3DS-66-A-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | SHAPE CUT THRU PANEL FULL DEPTH | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
Sculpt Tile A1 | SCULPT TILE A1 | E3DS-66-A1-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | SHAPE CUT THRU PANEL FULL DEPTH | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
Sculpt Tile A1-1 | SCULPT TILE A1 | E3DS-66-A1-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | SHAPE CUT THRU PANEL FULL DEPTH | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
