Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Sculpt\Sculpt Tile A.IFC
Time: 2024-11-01T11:22:18+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 9.9362368294722856; Volume Measure: 0.0099362368294723; Area Measure: 2.4140226684384114

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 9.9362368294722856; Volume Measure: 0.0099362368294723; Area Measure: 2.4140226684384114

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 9.9362368294722856; Volume Measure: 0.0099362368294723; Area Measure: 2.4140226684384114

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
Sculpt Tile A | PSet_Mass_Property - Mass Measure: 9.9362368294722856; Volume Measure: 0.0099362368294723; Area Measure: 2.4140226684384114
Sculpt Tile A | SOLIDWORKS Custom Properties - Description: SCULPT TILE A; PartNo: E3DS-66-A-000; Revision: A; Material: 9MM & 12MM EKKO ACOUSTIC PANEL; Finish: SHAPE CUT THRU PANEL FULL DEPTH; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
