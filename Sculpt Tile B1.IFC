Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Sculpt\Sculpt Tile B1.IFC
Time: 2024-11-01T11:20:55+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 8.4834420373495494; Volume Measure: 0.0084834420373495; Area Measure: 2.0815761385424807

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 8.4834420373495494; Volume Measure: 0.0084834420373495; Area Measure: 2.0815761385424807

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 8.4834420373495494; Volume Measure: 0.0084834420373495; Area Measure: 2.0815761385424807

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
Sculpt Tile B1 | PSet_Mass_Property - Mass Measure: 8.4834420373495494; Volume Measure: 0.0084834420373495; Area Measure: 2.0815761385424807
Sculpt Tile B1 | SOLIDWORKS Custom Properties - Description: SCULPT TILE B1; PartNo: E3DS-66-B1-000; Revision: A; Material: 9MM & 12MM EKKO ACOUSTIC PANEL; Material thickness: SHAPE CUT THRU PANEL FULL DEPTH; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
