Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Sculpt\Sculpt Tile Asembly B & B1.IFC
Time: 2024-11-01T11:19:58+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 33.9337681884015225; Volume Measure: 0.0339337681884015; Area Measure: 8.3263045526636184

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 33.9337681884015225; Volume Measure: 0.0339337681884015; Area Measure: 8.3263045526636184

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 33.9337681884015225; Volume Measure: 0.0339337681884015; Area Measure: 8.3263045526636184

# IfcBuildingElementProxy (5)
In: default BuildingStorey
Name | Description | PartNo | Revision | Material | CheckedBy | DrawnBy | Client | Project | sets with these values
Sculpt Tile Asembly B & B1 | PSet_Mass_Property - Mass Measure: 33.9337681884015225; Volume Measure: 0.0339337681884015; Area Measure: 8.3263045526636184
Sculpt Tile B | SCULPT TILE B | E3DS-66-B-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SOLIDWORKS Custom Properties - Finish: SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile B1 | SCULPT TILE B1 | E3DS-66-B1-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SOLIDWORKS Custom Properties - Material thickness: SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile B-1 | SCULPT TILE B | E3DS-66-B-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SOLIDWORKS Custom Properties - Finish: SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile B1-1 | SCULPT TILE B1 | E3DS-66-B1-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SOLIDWORKS Custom Properties - Material thickness: SHAPE CUT THRU PANEL FULL DEPTH
