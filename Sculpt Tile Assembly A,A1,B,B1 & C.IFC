Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Sculpt\Sculpt Tile Assembly A,A1,B,B1 & C.IFC
Time: 2024-11-01T11:18:48+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 243.3740876825736166; Volume Measure: 0.2433740876825736; Area Measure: 59.6183435544148566

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 243.3740876825736166; Volume Measure: 0.2433740876825736; Area Measure: 59.6183435544148566

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 243.3740876825736166; Volume Measure: 0.2433740876825736; Area Measure: 59.6183435544148566

# IfcBuildingElementProxy (29)
In: default BuildingStorey
Name | Description | PartNo | Revision | Material | CheckedBy | DrawnBy | Client | Project | sets with these values | Finish
Sculpt Tile Assembly A,A1,B,B1 & C | PSet_Mass_Property - Mass Measure: 243.3740876825736166; Volume Measure: 0.2433740876825736; Area Measure: 59.6183435544148566
Sculpt Tile B1 | SCULPT TILE B1 | E3DS-66-B1-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SOLIDWORKS Custom Properties - Material thickness: SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile A | SCULPT TILE A | E3DS-66-A-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile B | SCULPT TILE B | E3DS-66-B-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile B1-1 | SCULPT TILE B1 | E3DS-66-B1-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SOLIDWORKS Custom Properties - Material thickness: SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile A-1 | SCULPT TILE A | E3DS-66-A-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile B1-2 | SCULPT TILE B1 | E3DS-66-B1-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SOLIDWORKS Custom Properties - Material thickness: SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile B-1 | SCULPT TILE B | E3DS-66-B-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile B1-3 | SCULPT TILE B1 | E3DS-66-B1-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SOLIDWORKS Custom Properties - Material thickness: SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile B-2 | SCULPT TILE B | E3DS-66-B-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile A1 | SCULPT TILE A1 | E3DS-66-A1-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile B1-4 | SCULPT TILE B1 | E3DS-66-B1-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SOLIDWORKS Custom Properties - Material thickness: SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile A1-1 | SCULPT TILE A1 | E3DS-66-A1-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile A-2 | SCULPT TILE A | E3DS-66-A-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile A1-2 | SCULPT TILE A1 | E3DS-66-A1-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile A1-3 | SCULPT TILE A1 | E3DS-66-A1-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile A-3 | SCULPT TILE A | E3DS-66-A-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile B1-5 | SCULPT TILE B1 | E3DS-66-B1-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SOLIDWORKS Custom Properties - Material thickness: SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile B-3 | SCULPT TILE B | E3DS-66-B-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile B-4 | SCULPT TILE B | E3DS-66-B-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile B-5 | SCULPT TILE B | E3DS-66-B-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile C | SCULPT TILE C | E3DS-66-C-000 | A | 12MM & 9MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | PROFILES CUT THRU FULL DEPTH
Sculpt Tile B1-6 | SCULPT TILE B1 | E3DS-66-B1-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SOLIDWORKS Custom Properties - Material thickness: SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile C-1 | SCULPT TILE C | E3DS-66-C-000 | A | 12MM & 9MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | PROFILES CUT THRU FULL DEPTH
Sculpt Tile B-6 | SCULPT TILE B | E3DS-66-B-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile B1-7 | SCULPT TILE B1 | E3DS-66-B1-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SOLIDWORKS Custom Properties - Material thickness: SHAPE CUT THRU PANEL FULL DEPTH
Sculpt Tile C-2 | SCULPT TILE C | E3DS-66-C-000 | A | 12MM & 9MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | PROFILES CUT THRU FULL DEPTH
Sculpt Tile C-3 | SCULPT TILE C | E3DS-66-C-000 | A | 12MM & 9MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | PROFILES CUT THRU FULL DEPTH
Sculpt Tile B-7 | SCULPT TILE B | E3DS-66-B-000 | A | 9MM & 12MM EKKO ACOUSTIC PANEL | DG | CAM | EKKO | EKKO PRODUCT LIST | 2 | SHAPE CUT THRU PANEL FULL DEPTH
