Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Sculpt\Sculpt Tile C.IFC
Time: 2024-11-01T11:20:27+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 7.0372800000000009; Volume Measure: 0.0070372800000000; Area Measure: 1.7502360000000023

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 7.0372800000000009; Volume Measure: 0.0070372800000000; Area Measure: 1.7502360000000023

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 7.0372800000000009; Volume Measure: 0.0070372800000000; Area Measure: 1.7502360000000023

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
Sculpt Tile C | PSet_Mass_Property - Mass Measure: 7.0372800000000009; Volume Measure: 0.0070372800000000; Area Measure: 1.7502360000000023
Sculpt Tile C | SOLIDWORKS Custom Properties - Description: SCULPT TILE C; PartNo: E3DS-66-C-000; Revision: A; Material: 12MM & 9MM EKKO ACOUSTIC PANEL; Finish: PROFILES CUT THRU FULL DEPTH; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
