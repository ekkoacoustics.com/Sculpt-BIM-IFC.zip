Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Sculpt\Sculpt Tile B.IFC
Time: 2024-11-01T11:21:21+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 8.4834420568512137; Volume Measure: 0.0084834420568512; Area Measure: 2.0815761377893285

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 8.4834420568512137; Volume Measure: 0.0084834420568512; Area Measure: 2.0815761377893285

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 8.4834420568512137; Volume Measure: 0.0084834420568512; Area Measure: 2.0815761377893285

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
Sculpt Tile B | PSet_Mass_Property - Mass Measure: 8.4834420568512137; Volume Measure: 0.0084834420568512; Area Measure: 2.0815761377893285
Sculpt Tile B | SOLIDWORKS Custom Properties - Description: SCULPT TILE B; PartNo: E3DS-66-B-000; Revision: A; Material: 9MM & 12MM EKKO ACOUSTIC PANEL; Finish: SHAPE CUT THRU PANEL FULL DEPTH; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
